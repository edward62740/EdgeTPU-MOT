# Keil uVision project RTX_CM.uvprojx, settings and files
target CM0_LE (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM0 (library)
  AfterMake: cmd.exe /C copy CM0_LE\RTX_CM0.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Configuration
    ../../: RTX_Config.h
  group Core
    ../../../Source/: rtx_kernel.c rtx_thread.c rtx_delay.c rtx_timer.c rtx_evflags.c rtx_mutex.c rtx_semaphore.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_system.c rtx_evr.c
    ../../../../Source/: os_systick.c
  group Handlers
    ../../../Source/GCC/: irq_armv6m.S irq_armv7m.S irq_armv8mbl.S irq_armv8mml.S
target CM3_LE (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy CM3_LE\RTX_CM3.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target CM4F_LE (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTX_CM4F (library)
  AfterMake: cmd.exe /C copy CM4F_LE\RTX_CM4F.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBL_LE (6160000::V6.16::ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MBL") CLOCK(12000000) ELITTLE
  output: RTX_V8MB (library)
  AfterMake: cmd.exe /C copy ARMv8MBL_LE\RTX_V8MB.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MBL_NS_LE (6160000::V6.16::ARMCLANG)
  device: ARMv8MBL ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RTX_V8MBN (library)
  AfterMake: cmd.exe /C copy ARMv8MBL_NS_LE\RTX_V8MBN.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE DO***REMOVED***_NS=1
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm define: DO***REMOVED***_NS=1
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_LE (6160000::V6.16::ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") CLOCK(12000000) ELITTLE
  output: RTX_V8MM (library)
  AfterMake: cmd.exe /C copy ARMv8MML_LE\RTX_V8MM.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_NS_LE (6160000::V6.16::ARMCLANG)
  device: ARMv8MML ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RTX_V8MMN (library)
  AfterMake: cmd.exe /C copy ARMv8MML_NS_LE\RTX_V8MMN.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE DO***REMOVED***_NS=1
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm define: DO***REMOVED***_NS=1
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_SP_LE (6160000::V6.16::ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("ARMV8MML") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: RTX_V8MMF (library)
  AfterMake: cmd.exe /C copy ARMv8MML_SP_LE\RTX_V8MMF.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMv8MML_SP_NS_LE (6160000::V6.16::ARMCLANG)
  device: ARMv8MML_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RTX_V8MMFN (library)
  AfterMake: cmd.exe /C copy ARMv8MML_SP_NS_LE\RTX_V8MMFN.lib ..\.
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EVR_RTX_DISABLE DO***REMOVED***_NS=1
  c include: ..\..\..\Library;..\..\..\Include;..\..\..\..\Include
  asm define: DO***REMOVED***_NS=1
  asm include: .;..\..\..\Library;..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.4.0
