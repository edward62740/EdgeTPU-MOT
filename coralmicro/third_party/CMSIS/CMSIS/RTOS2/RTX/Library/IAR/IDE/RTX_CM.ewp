# IAR project RTX_CM.ewp, settings and files
configuration CM0 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMCM0.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM0\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\Library; ..\..\..\Include
  ILINK.IlinkOutputFile: RTX_CM.out
configuration CM3 (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMCM3.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM3\Include
configuration CM4F (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMCM4_FP.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM4\Include
configuration V8MB (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv8MBL.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMv8MBL\Include
configuration V8MBN (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv8MBL.h"; EVR_RTX_DISABLE; DO***REMOVED***_NS=1
  ICCARM.CCIncludePath2: as above
configuration V8MM (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv8MML.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMv8MML\Include
configuration V8MMN (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv8MML.h"; EVR_RTX_DISABLE; DO***REMOVED***_NS=1
  ICCARM.CCIncludePath2: as above
configuration V8MMF (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv8MML_SP.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: as above
configuration V8MMFN (ARM)
  as the first configuration, except:
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv8MML_SP.h"; EVR_RTX_DISABLE; DO***REMOVED***_NS=1
  ICCARM.CCIncludePath2: as above
configuration V81MM (ARM)
  as the first configuration, except:
  General.CoreVariant: 61
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv81MML_DSP_DP_MVE_FP.h"; EVR_RTX_DISABLE
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMv81MML\Include
configuration V81MMN (ARM)
  as the first configuration, except:
  General.CoreVariant: 61
  ICCARM.CCDefines: NDEBUG; CMSIS_device_header="ARMv81MML_DSP_DP_MVE_FP.h"; EVR_RTX_DISABLE; DO***REMOVED***_NS=1
  ICCARM.CCIncludePath2: as above
configuration V81MMF (ARM)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
configuration V81MMFN (ARM)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  group Core
    ../../../../Source/: os_systick.c
    ../../../Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group Handlers
    ../../../Source/IAR/: irq_armv6m.s irq_armv7m.s irq_armv8mbl.s irq_armv8mml.s
